# Keil uVision project clkSelect.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BAT32A237KH64FB Cmsemicon
  pack: Cmsemicon.BAT32A237.1.0.5
  cpu: IRAM(0x20000000,0x03000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,BAT32A237_64PIN
  c include: ..\..\..\Device\Include;..\..\..\Driver\include;..\app\include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ../: main.c
  group App
    ../app/src/: retarget.c uart_demo.c tim_demo.c
  group Bsp
    ../../../Driver/src/: gpio.c sci_common.c uart.c cgc.c isr.c pcbz.c tim.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
